# IAR project APP.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\
  ICC8051.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\; api\; display\; display\lcd\; display\lcdseg\; display\led\; display\ledseg\; display\no\; config\; common\; task\; user\; user\mp3res\; btstack\; user\user_config; user\user_iis
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  prebuild: $TARGET_DIR$\pre.bat
  postbuild: $TARGET_DIR$\make.bat
  XLINK.XclFile: APP_BASE.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCIncludePaths: $TOOLKIT_DIR$\INC\
  ICC8051.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: APP.xcl APP_BASE.xcl main.c makecfg.c
    Debug/Exe/: hexscript.hs
  group config
    config/: config.c
  group display
    display/: display.c ocx.c TM1629.c
  group display/lcd
    display/lcd/: checkbox.c display_mem.c filelist.c lcd.c lcd_display.c listbox.c listboxa.c msgbox.c numbox.c progressbox.c
  group display/lcdseg
    display/lcdseg/: lcdseg_display.c lcdseg_listbox.c lcdseg_msgbox.c lcdseg_numbox.c lcdseg_progressbox.c
  group display/led
    display/: led.c
  group display/ledseg
    display/ledseg/: led_5c7s.c led_7p7s.c led_seg.c ledseg_display.c ledseg_listbox.c ledseg_msgbox.c ledseg_numbox.c ledseg_progressbox.c
  group display/no
    display/no/: no_theme.c
  group task
    task/: task.c task_alarm.c task_aux_eq.c task_bt.c task_bt_hid.c task_clock.c task_CS8416.c task_fm.c task_hold.c task_idle.c task_menu.c task_music.c task_NPCP215X.c task_poweroff.c task_record.c task_show_time.c task_speaker.c task_STA350.c task_tomcat.c task_update_fw.c task_usbdev.c task_voice.c
  group task/sub
    task/sub/: tasksub_bt_call.c tasksub_bt_lost.c tasksub_bt_menu.c tasksub_bt_ring.c tasksub_bt_test.c tasksub_fm_record.c tasksub_fm_recplay.c tasksub_music_menu.c tasksub_recording.c tasksub_recplay.c
  group user
    user/: file_filter.c uart_drv.c user_amux.c user_bt.c user_bt_pbap.c user_bt_spp.c user_eq.c user_fat.c user_fft_led.c user_fm.c user_iis.c user_io.c user_ir.c user_key.c user_music.c user_record.c user_setting.c user_spi.c user_sys.c user_timer.c user_uart.c
  group user/user_fm
    user/user_fm/: user_fm_ax5111.c user_fm_bk1080.c user_fm_qn8035.c user_fm_qn8065.c user_fm_rda5807.c user_fm_RTC6207.c user_fm_RTC6218.c
  group user/user_iis
    user/user_iis/: user_tas5711.c
